options:
  parameters:
    generate_options: qt_gui
    id: challenge
    output_language: python
    title: 'What Lurks Below: ASK'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: for inspectrum
    file: /tmp/ask.cfile
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    comment: for wpcr.py
    file: /tmp/demod.dat
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/challenge.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: channel filter for ASK signal
    cutoff_freq: 20e3
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"ASK Signal"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
